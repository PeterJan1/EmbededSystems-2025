Commit message: Another awesome robotics class DH param

File: urdf/2dof_planar_robot.urdf (robot description, URDF)
Before this commit: robot 2dof_planar_robot, 4 links, 3 joints
Links:
- added link ee
Joints:
- added joint joint3: type fixed, parent link2, child ee, origin xyz=0 0 1 rpy=0 0 0
